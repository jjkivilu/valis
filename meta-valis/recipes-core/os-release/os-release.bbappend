OS_RELEASE_FIELDS_append += "BUILD_ID"
