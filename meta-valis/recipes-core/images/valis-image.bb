SUMMARY = "Phony target for final image, which is just kernel+initramfs bundle"
LICENSE = "MIT"
DEPENDS = "virtual/kernel ${INITRAMFS_IMAGE}"
